# Keil uVision project mbed_dimmer.uvproj, settings and files
target mbed FRDM-KL05Z (ARM-ADS)
  device: MKL05Z32xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: mbed_dimmer
  AfterMake: fromelf --bin -o build\mbed_dimmer_KL05Z.bin build\mbed_dimmer.axf
  c flags: Optim=1 uC99=1
  c define: TARGET_KL05Z,  TARGET_M0P,  TARGET_CORTEX_M,  TARGET_Freescale,  TARGET_KLXX,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M0PLUS,  ARM_MATH_CM0PLUS,  MBED_BUILD_TIMESTAMP=1429070272.35,  __MBED__=1,  TARGET_FF_ARDUINO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;mbed;mbed/TARGET_KL05Z;mbed/TARGET_KL05Z/TARGET_Freescale;mbed/TARGET_KL05Z/TARGET_Freescale/TARGET_KLXX;mbed/TARGET_KL05Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL05Z;mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  scatter file: mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/MKL05Z4.sct
  link misc: mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/system_MKL05Z4.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/mbed_overrides.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/startup_MKL05Z4.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_KL05Z/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
    ./: TSI_Sensor.h TSI_Sensor .cpp
